# Keil uVision project Template.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  AfterMake: D:\keil MDK\ARM\ARMCC\bin\fromelf.exe  --bin -o "$LTemplate.bin" "#L"
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS\Inc;..\Drives\Inc;..\FWLIB\Inc;..\FWLIB\SystemInc;..\Interrupt\Inc;..\task\Inc;..\UCOSII\Inc;..\UCOSII\user;..\IRMP\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Project
    ./: main.c
  group Task
    ../task/Src/: task.c
  group IRMP
    ../IRMP/src/: irmp.c irmptime.c
  group System
    ../Drives/Src/: sys.c usart.c delay.c
  group Interrupt
    ../Interrupt/Src/: stm32f10x_it.c
  group FWLIB
    ../FWLIB/Src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../FWLIB/SystemSrc/: system_stm32f10x.c
  group StartUp
    ../FWLIB/StartUp/: startup_stm32f10x_hd.s
  group CMSIS
    ../CMSIS/Src/: core_cm3.c
  group OSCORE
    ../UCOSII/Src/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group OSPORT
    ../UCOSII/user/: os_cpu_a.asm os_cpu_c.c os_dbg.c
    ../UCOSII/Inc/: os_cpu.h
  group OSCONFIG
    ../UCOSII/Inc/: includes.h os_cfg.h
software components: CMSIS:CORE 5.0.1
